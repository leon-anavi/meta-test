DESCRIPTION = "Example Package with 100MB of content"
LICENSE = "MIT"
PR = "1"

include test-package.inc
