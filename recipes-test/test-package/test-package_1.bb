DESCRIPTION = "Example Package with 1MB of content"
LICENSE = "MIT"
PR = "1"

include test-package.inc
