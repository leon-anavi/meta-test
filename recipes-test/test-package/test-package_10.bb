DESCRIPTION = "Example Package with 10MB of content"
LICENSE = "MIT"
PR = "1"

include test-package.inc
